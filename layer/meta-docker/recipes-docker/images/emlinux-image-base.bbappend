# Add packages for Docker
IMAGE_PREINSTALL:append = " \
    ca-certificates \
    connman \
    docker.io \
"
