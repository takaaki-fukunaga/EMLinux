# Add packages for K3s
IMAGE_PREINSTALL:append = " \
    ca-certificates \
    connman \
"
