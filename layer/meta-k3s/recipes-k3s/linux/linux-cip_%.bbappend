FILESEXTRAPATHS:prepend := "${FILE_DIRNAME}/files:"

SRC_URI += "file://qemu-arm64_k3s_defconfig"
